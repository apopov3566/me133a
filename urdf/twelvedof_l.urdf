Commit message: Add axis prioritization

File: urdf/twelvedof_l.urdf (robot description, URDF)
Before this commit: robot twelvedof, 48 links, 47 joints
Links:
- link mount12: geometry collision cylinder length=0.4 radius=0.01; visual cylinder length=0.4 radius=0.01
